options:
  parameters:
    author: lab3_qpsk_antsdr
    generate_options: qt_gui
    id: lab3_qpsk_antsdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: QPSK
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '128'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: timing_loop_bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '.001'
    step: '.001'
    stop: '.2'
    value: '.062'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wcc/Desktop/gnuradio_demo/Chapter8/text_out.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '19'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.01'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: len_key2
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.068'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: digital.psk_4()[1]
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: '1500000'
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1500000'
    uri: uri
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    name: QPSK TX
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uri
  id: parameter
  parameters:
    label: uri
    type: str
    value: ip:192.168.1.10
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_protocol_formatter_bb_0_0_0, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', digital_constellation_modulator_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_protocol_formatter_bb_0_0_0, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [iio_pluto_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
