options:
  parameters:
    author: wcc
    generate_options: qt_gui
    id: am_dsb_tc_demod
    output_language: python
    title: am_dsb_tc_demod
  states: {}

blocks:
- name: bband_duc
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '5'
    samp_rate: 48e3
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rx_lo_freq
  id: variable
  parameters:
    value: '499960000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: '500000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '5'
    gain: '1'
    high_cutoff_freq: 55e3
    low_cutoff_freq: 25e3
    samp_rate: '960000'
    type: fir_filter_ccf
    width: 4e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wcc/GNU_Radio/audio/music1_mono48kHz.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: tx_lo_freq
    samplerate: '960000'
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: rx_lo_freq
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '960000'
    uri: uri
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '20'
    taps: bband_duc
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '20'
    gain: '1'
    interp: '1'
    samp_rate: '960000'
    type: interp_fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '4'
    gain: '1'
    samp_rate: 192e3
    type: fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_abs_xx_0, '0', low_pass_filter_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_abs_xx_0, '0']
- [blocks_float_to_complex_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_const_vxx_0, '0']
- [iio_pluto_source_0, '0', band_pass_filter_0, '0']
- [interp_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
