options:
  parameters:
    author: wcc
    generate_options: qt_gui
    id: lab3_bpsk_text
    output_language: python
    title: lab3_bpsk_text
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: freq_offset
    orient: Qt.Horizontal
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '25'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.0'
    step: '.001'
    stop: '1'
    value: '.063'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: timing_loop_bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '.001'
    step: '.001'
    stop: '.2'
    value: '.062'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wcc/Desktop/gnuradio_demo/Chapter7/text_out.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wcc/Desktop/gnuradio_demo/Chapter7/text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '19'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '19'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset/samp_rate
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0 '
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: len_key2
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.05'
  states: {}
- name: digital_lms_dd_equalizer_cc_1
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: BPSK
    mu: '0.01'
    num_taps: '8'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: result
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_protocol_formatter_bb_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_throttle_0, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [channels_channel_model_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', digital_lms_dd_equalizer_cc_1, '0']
- [digital_lms_dd_equalizer_cc_1, '0', blocks_complex_to_real_0, '0']
- [digital_lms_dd_equalizer_cc_1, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0_0_0, '0', blocks_tagged_stream_mux_0_0_0, '0']

metadata:
  file_format: 1
