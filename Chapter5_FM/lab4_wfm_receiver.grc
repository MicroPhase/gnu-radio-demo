options:
  parameters:
    author: wcc
    generate_options: qt_gui
    id: lab4_wfm_receiver
    output_language: python
    title: lab4_wfm_receiver
  states: {}

blocks:
- name: bband_samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: local_freq
  id: variable_qtgui_range
  parameters:
    label: local_freq
    orient: Qt.Horizontal
    rangeType: int
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: int(100.1e6)
  states: {}
- name: rf_band_width
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: rf_band_width
    bbdc: 'True'
    buffer_size: '32768'
    frequency: local_freq-15
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: bband_samp_rate
    uri: uri
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate*20
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate*5
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*20
    fc: '0'
    fftsize: '1024'
    name: '"rx spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.1.10
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', low_pass_filter_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [iio_pluto_source_0, '0', blocks_conjugate_cc_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_1, '0', low_pass_filter_1_0, '0']
- [low_pass_filter_1_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
